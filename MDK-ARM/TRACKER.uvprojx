# Keil uVision project TRACKER.uvprojx, settings and files
target TRACKER (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302RB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TRACKER
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302xC
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c main.c stm32f3xx_it.c uart_printf.h power_button.h power_button.c program.h program.c sleepmode.h sleepmode.c eeprom.c eeprom.h tinygps.c tinygps.h
    ../Inc/: main.h
    ../src/: gpsmodule.h gpsmodule.c
  group Application/MDK-ARM
    ./: startup_stm32f302xc.s
software components: CMSIS:CORE 4.1.0
